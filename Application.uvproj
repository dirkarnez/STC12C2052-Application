# Keil uVision project Application.uvproj, settings and files
target Application (MCS-51)
  device: STC12C2052AD Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: Application +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 main.c
